# drop the 'destsuffix' so we make the oe-core backports easier without conflits
SRC_URI = "git://go.googlesource.com/example;branch=master;protocol=https"
