inherit pkgconfig

DEPENDS += "zstd"
