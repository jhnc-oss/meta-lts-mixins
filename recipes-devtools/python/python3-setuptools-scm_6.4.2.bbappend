# This seems required to reliably build python3-setuptools-scm-native
DEPENDS += "python3-tomli-native"