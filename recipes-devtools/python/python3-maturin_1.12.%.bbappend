DEPENDS += "zstd"

inherit pkgconfig
