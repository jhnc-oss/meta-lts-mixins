PTEST_RUNNER_TIMEOUT:virtclass-mcextend-go = "4800"

# golang go-ptest requires extra space
IMAGE_ROOTFS_EXTRA_SPACE:virtclass-mcextend-go = "1524288"

QB_MEM:virtclass-mcextend-go = "-m 4096"
