GOTOOLS = "\
    go-helloworld \
    cgo-helloworld \
    "
